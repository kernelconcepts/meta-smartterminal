FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
FILES:${PN}-dev = ""
ALLOW_EMPTY:${PN}-dev = "0"
