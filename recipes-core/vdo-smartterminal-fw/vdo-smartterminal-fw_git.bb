require vdo-smartterminal-fw.inc
