SRC_URI = "git://github.com/rhinstaller/libbytesize;branch=main;protocol=https"
