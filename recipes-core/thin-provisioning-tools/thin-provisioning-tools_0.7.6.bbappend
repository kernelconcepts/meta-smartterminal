SRC_URI = "git://github.com/jthornber/thin-provisioning-tools;branch=main;protocol=https \
           file://0001-do-not-strip-pdata_tools-at-do_install.patch \
           file://0001-fix-compile-failed-with-libc-musl.patch \
"
