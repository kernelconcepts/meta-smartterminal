SRC_URI = "git://github.com/lz4/lz4.git;protocol=https \
           file://run-ptest \
"
