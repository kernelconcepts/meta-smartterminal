FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"

SRC_URI:append = " file://0001-Add-timeout-0-to-wait-for-ever.patch \
                 "
