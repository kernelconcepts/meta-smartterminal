FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

RDEPENDS_${BPN} += "dotsplash-theme-slideshow"
